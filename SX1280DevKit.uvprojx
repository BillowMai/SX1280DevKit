# Keil uVision project SX1280DevKit.uvprojx, settings and files
target SX1280DevKit (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SX1280DevKit
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DTARGET_NUCLEO_L476RG -DDEVICE_PORTINOUT=1 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti --split_sections -DTARGET_STM32L476RG -DTARGET_FF_MORPHO -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DDEVICE_I2C=1 -D__FPU_PRESENT=1 -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DMBED_BUILD_TIMESTAMP=1512539737.77 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DTARGET_STM32L4 -DDEVICE_PORTIN=1 -DTARGET_M4 -DTARGET_CORTEX -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM
  c include: .; Demo; Demo/SX1280Lib; Display; Display/DmTftLibrary; Peripherals; mbed/.; mbed/TARGET_NUCLEO_L476RG; mbed/TARGET_NUCLEO_L476RG/TARGET_STM; mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4; mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_NUCLEO_L476RG; mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__FPU_PRESENT=1,-DARM_MATH_CM4,-D__CORTEX_M4,-D__MBED_CMSIS_RTOS_CM
  asm include: .; Demo; Demo/SX1280Lib; Display; Display/DmTftLibrary; Peripherals; mbed/.; mbed/TARGET_NUCLEO_L476RG; mbed/TARGET_NUCLEO_L476RG/TARGET_STM; mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4; mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_NUCLEO_L476RG; mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD;
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD/stm32l476xx.sct
  link misc: --show_full_path
  group Demo
    Demo/: DemoApplication.cpp DemoApplication.h FreqLUT.h
    Demo/SX1280Lib/: radio.h sx1280-hal.cpp sx1280-hal.h sx1280.cpp sx1280.h
  group Display
    Display/: DisplayDriver.cpp DisplayDriver.h Menu.cpp Menu.h SemtechLogo.c
    Display/DmTftLibrary/: dm_platform.h DmTftBase.cpp DmTftBase.h DmTftHX8353C.cpp DmTftHX8353C.h DmTftIli9325.cpp DmTftIli9325.h DmTftIli9341.cpp DmTftIli9341.h DmTftRa8875.cpp DmTftRa8875.h DmTftS6D0164.cpp DmTftS6D0164.h DmTftSsd2119.cpp DmTftSsd2119.h DmTouch.cpp DmTouch.h DmTouchCalibration.cpp DmTouchCalibration.h DmTpFt6x06.cpp DmTpFt6x06.h font.c
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Driver_Common.h Driver_Storage.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h pinmap.h platform.h PlatformMutex.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h SingletonPtr.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_NUCLEO_L476RG/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32l476xx.h stm32l4xx.h stm32l4xx_hal.h stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.h stm32l4xx_hal_comp.h stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dma.h stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.h stm32l4xx_hal_nand.h stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.h stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.h stm32l4xx_hal_sd.h stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.h stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.h stm32l4xx_ll_crs.h stm32l4xx_ll_dac.h stm32l4xx_ll_dma.h stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.h stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.h stm32l4xx_ll_usart.h stm32l4xx_ll_usb.h stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h system_stm32l4xx.h
    mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD/: cmsis_nvic.o hal_tick.o mbed.ar mbed_board.o mbed_overrides.o retarget.o startup_stm32l476xx.o stm32l4xx_hal.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o stm32l4xx_hal_can.o stm32l4xx_hal_comp.o stm32l4xx_hal_cortex.o stm32l4xx_hal_crc.o stm32l4xx_hal_crc_ex.o stm32l4xx_hal_cryp.o stm32l4xx_hal_cryp_ex.o stm32l4xx_hal_dac.o stm32l4xx_hal_dac_ex.o stm32l4xx_hal_dfsdm.o stm32l4xx_hal_dma.o stm32l4xx_hal_firewall.o stm32l4xx_hal_flash.o stm32l4xx_hal_flash_ex.o stm32l4xx_hal_flash_ramfunc.o stm32l4xx_hal_gpio.o stm32l4xx_hal_hcd.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_irda.o stm32l4xx_hal_iwdg.o stm32l4xx_hal_lcd.o stm32l4xx_hal_lptim.o stm32l4xx_hal_msp_template.o stm32l4xx_hal_nand.o stm32l4xx_hal_nor.o stm32l4xx_hal_opamp.o stm32l4xx_hal_opamp_ex.o stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_qspi.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rng.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_sai.o stm32l4xx_hal_sd.o stm32l4xx_hal_smartcard.o stm32l4xx_hal_smartcard_ex.o stm32l4xx_hal_smbus.o stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.o stm32l4xx_hal_sram.o stm32l4xx_hal_swpmi.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_hal_tsc.o stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.o stm32l4xx_hal_usart.o stm32l4xx_hal_wwdg.o stm32l4xx_ll_adc.o stm32l4xx_ll_comp.o stm32l4xx_ll_crc.o stm32l4xx_ll_crs.o stm32l4xx_ll_dac.o stm32l4xx_ll_dma.o stm32l4xx_ll_exti.o stm32l4xx_ll_fmc.o stm32l4xx_ll_gpio.o stm32l4xx_ll_i2c.o stm32l4xx_ll_lptim.o stm32l4xx_ll_lpuart.o stm32l4xx_ll_opamp.o stm32l4xx_ll_pwr.o stm32l4xx_ll_rcc.o stm32l4xx_ll_rng.o stm32l4xx_ll_rtc.o stm32l4xx_ll_sdmmc.o stm32l4xx_ll_spi.o stm32l4xx_ll_swpmi.o stm32l4xx_ll_tim.o stm32l4xx_ll_usart.o stm32l4xx_ll_usb.o stm32l4xx_ll_utils.o sys.o system_stm32l4xx.o
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/: common_objects.h device.h gpio_object.h PeripheralPins.h rtc_api_hal.h
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_NUCLEO_L476RG/: objects.h PeripheralNames.h PinNames.h PortNames.h
  group Peripherals
    Peripherals/: Eeprom.cpp Eeprom.h GpsMax7.cpp GpsMax7.h SX9306.cpp SX9306.h Timers.cpp Timers.h
  group SX1280DevKit
    ./: main.cpp main.h mbed_config.h
